<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MCU_STM32F103RCx.ewp</path>
  </project>
  <batchBuild />
</workspace>
